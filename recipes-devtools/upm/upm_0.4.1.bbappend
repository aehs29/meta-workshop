FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://0001-calamari-adds-module-for-Minnowboard-MAX-Calamari-Lu.patch"
